## solutions/videopuerto/main/Kconfig.projbuild
```kconfig
menu "Compat esp_video/esp_h264"

config ESP_VIDEO_USE_CUSTOMIZED_ESP_H264_VERSION
    bool
    default n

endmenu
```
